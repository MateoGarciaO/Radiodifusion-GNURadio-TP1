options:
  parameters:
    author: mateo
    generate_options: qt_gui
    id: TP12c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: min_fase
  id: variable
  parameters:
    value: (np.pi*2*(1e6+1e3)/samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: |-
      Detecta la portadora y me devuelve 
      la portadora por la señal
    max_freq: '-min_fase'
    min_freq: min_fase
    w: '0.04'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mateo/Desktop/Link to UCA/Radiodifusion/Ejercicios/TP1GNU/TP1-2a-AM.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: La amplifico xq sale muy atenuada
    const: '5'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: Componente Continua
    cutoff_freq: '100'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (0,0)
    label1: Modulada
    label2: Demodulada
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (1,0)
    label1: Señal Modulada
    label2: Señal Demodulada
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', low_pass_filter_1, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_1, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_1, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
