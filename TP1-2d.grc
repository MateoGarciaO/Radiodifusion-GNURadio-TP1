options:
  parameters:
    author: mateo
    generate_options: qt_gui
    id: TP12d
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: CoefMod
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Coeficiente de modulacion
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (0,0)
    type: float
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    comment: Detector de envolvente
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/mateo/Desktop/Link to UCA/Radiodifusion/Ejercicios/TP1GNU/TP1-2a-AM.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_peak_detector2_fb_0_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_rise: '7'
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_fall: '1'
    threshold_factor_rise: '1'
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: Componente Continua
    cutoff_freq: '100'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (2,0)
    label1: Modulada
    label2: Demodulada
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Modulada
    label2: Demodulada
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Continua
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Modulada
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Pico
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Pico
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Continua
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Modulada
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Modulada
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', low_pass_filter_0_1, '0']
- [blocks_divide_xx_0, '0', CoefMod, '0']
- [blocks_file_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_file_source_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_peak_detector2_fb_0_0, '0', blocks_sample_and_hold_xx_0_0, '1']
- [blocks_peak_detector_xb_0, '0', blocks_sample_and_hold_xx_0_1, '1']
- [blocks_sample_and_hold_xx_0_0, '0', virtual_sink_0_1, '0']
- [blocks_sample_and_hold_xx_0_1, '0', blocks_divide_xx_0, '1']
- [blocks_sample_and_hold_xx_0_1, '0', blocks_sub_xx_1, '1']
- [blocks_sub_xx_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_1, '0', blocks_divide_xx_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_sub_xx_0_0, '0']
- [low_pass_filter_0_0_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_peak_detector2_fb_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_sample_and_hold_xx_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_sub_xx_0_0, '1']
- [low_pass_filter_0_1, '0', low_pass_filter_0_0_0, '0']
- [virtual_source_0, '0', blocks_sub_xx_1, '0']
- [virtual_source_0_0, '0', blocks_peak_detector_xb_0, '0']
- [virtual_source_0_0, '0', blocks_sample_and_hold_xx_0_1, '0']
- [virtual_source_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
