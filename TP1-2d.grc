options:
  parameters:
    author: mateo
    generate_options: qt_gui
    id: TP12d
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ganancia
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mateo/Desktop/Link to UCA/Radiodifusion/Ejercicios/TP1GNU/TP1-2a-AM.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_max_xx_0_0_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Modulada
    label2: Demodulada
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Modulada
    label2: Demodulada
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [blocks_divide_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_file_source_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0_1, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_max_xx_0_0, '0', blocks_sub_xx_1_0, '0']
- [blocks_max_xx_0_0_0, '0', blocks_sub_xx_1_0, '1']
- [blocks_null_source_0, '0', blocks_max_xx_0_0_0, '1']
- [blocks_null_source_0_0, '0', blocks_max_xx_0_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_1_0, '0', blocks_divide_xx_0_0, '1']
- [low_pass_filter_0_0, '0', blocks_divide_xx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_max_xx_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_sub_xx_0_0, '1']
- [low_pass_filter_0_1, '0', blocks_max_xx_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_sub_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
