options:
  parameters:
    author: mateo
    generate_options: qt_gui
    id: TP11d
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Sintonizador
  id: variable_qtgui_range
  parameters:
    label: Sintonizador
    start: '-0.8e6'
    step: 200e3
    stop: 0.8e6
    value: '0'
  states: {}
- name: Taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 75e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Sintonizador
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mateo/Desktop/Link to UCA/Radiodifusion/Teoria/GRC/capturas/espectro_2M
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: Sintonizador
    decim: '1'
    samp_rate: samp_rate
    taps: Taps
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: Espectro Original
    label2: Emisora
    name: '"Filtrada"'
    nconnections: '2'
    norm_window: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0_1, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_throttle_0_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
